# Keil uVision project message_task_priority_display.uvprojx, settings and files
target stm32F4_jpf (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: message_task_priority_display +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000,ICCARM
  c include: C:\Keil_v5\FREERTOS\FreeRTOS\Source\include;C:\Keil_v5\FREERTOS\FreeRTOS\Demo\Common\include;C:\Keil_v5\FREERTOS\FreeRTOS\Source\portable\RVDS\ARM_CM4F;C:\Keil_v5\ARM\Device\ARM\ARMCM4\Include;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main_message_task.c
    ../Inc/: FreeRTOSConfig.h
  group Std_PeriphDirvier
    ./RTE/Device/STM32F429ZITx/: system_stm32f4xx.c
  group Start_up
    ./RTE/Device/STM32F429ZITx/: startup_stm32f429xx.s
  group FreeRtos
    C:/Keil_v5/FREERTOS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    C:/Keil_v5/FREERTOS/FreeRTOS/Demo/Common/Minimal/: AltBlckQ.c AltBlock.c AltPollQ.c AltQTest.c BlockQ.c blocktim.c comtest.c comtest_strings.c countsem.c crflash.c crhook.c death.c dynamic.c EventGroupsDemo.c flash.c flash_timer.c flop.c GenQTest.c integer.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c recmutex.c semtest.c sp_flop.c TimerDemo.c
  group Include
    C:/Keil_v5/FREERTOS/FreeRTOS/Source/include/: croutine.h event_groups.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h FreeRTOS.h
    C:/Keil_v5/ARM/Pack/Keil/STM32F4xx_DFP/2.2.0/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h
    C:/Keil_v5/ARM/Pack/ARM/CMSIS/4.1.1/CMSIS/Driver/Include/: Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h Driver_Flash.h Driver_I2C.h Driver_MCI.h Driver_NAND.h Driver_SPI.h Driver_USART.h Driver_USB.h Driver_USBD.h Driver_USBH.h
    C:/Keil_v5/FREERTOS/FreeRTOS/Demo/Common/include/: AltBlckQ.h AltBlock.h AltPollQ.h AltQTest.h BlockQ.h blocktim.h comtest.h comtest_strings.h comtest2.h countsem.h crflash.h crhook.h death.h dynamic.h EventGroupsDemo.h fileIO.h flash.h flash_timer.h flop.h GenQTest.h integer.h IntQueue.h mevents.h partest.h PollQ.h print.h QPeek.h QueueOverwrite.h QueueSet.h recmutex.h semtest.h serial.h TimerDemo.h
    C:/Keil_v5/FREERTOS/FreeRTOS/Demo/PIC32MX_MPLAB/: IntQueueTimer.h
  group Flash OPT
    ./: STM32F42xxx_43xxx_OPT.s
  group LIbrary
    C:/Users/keil/Documents/WORKSPACE STM/JPFtest/libraries/: FS_ARM_B.lib FS_ARM_L.lib FS_CM1.lib FS_CM3.lib FSN_ARM_B.lib FSN_ARM_L.lib FSN_CM1.lib FSN_CM3.lib MPS_CM0.LIB MPS_CM3.LIB RTX_ARM_B.lib RTX_ARM_L.lib RTX_ARM9F_B.lib RTX_ARM9F_L.lib RTX_CM1.lib RTX_CM1_B.lib RTX_CM3.lib RTX_CM3_B.lib RTX_CM3X.lib RTX_CM4.lib RTX_CM4_B.lib RTX_CR4.lib RTX_CR4_B.lib
  group ::Board Support
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/MDK/Boards/ST/STM32F429I-Discovery/Common/: Buttons_F429Discovery.c LED_F429Discovery.c
  group ::CMSIS Driver
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/CMSIS/Driver/: SPI_STM32F4xx.c
  group ::Device
    RTE/Device/STM32F429ZITx/: startup_stm32f429xx.s system_stm32f4xx.c RTE_Device.h stm32f4xx_hal_conf.h
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c
software components: CMSIS:CORE 3.30.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:SPI 2.00, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:DMA2D 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:RTC 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:Startup 2.1.0
